# Keil uVision project Bank.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\Timer;..\HARDWARE\ADC;..\HARDWARE\PWM;..\HARDWARE\IIC;..\HARDWARE\STMFLASH;..\HARDWARE\Key_Exit;..\HARDWARE\CAN;..\HARDWARE\Screen;..\HARDWARE\Screen\LCD;..\HARDWARE\Screen\OLED_IIC;..\HARDWARE\Screen\OLED_SPI;..\BSP
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group BSP
    ../BSP/: bsp_gpio.c bsp_timer.c bsp_timer_up_it.c bsp_pwm.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c zhead.h
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/Key_Exit/: key_exit.c
    ../HARDWARE/Screen/: screen.c
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/Timer/: Timer.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group COMMUNICAT
    ../SYSTEM/usart/: usart.c comm_usart.c HW_Usart.c
    ../HARDWARE/CAN/: can.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_can.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_wwdg.c
